# Autodesk Inventor part: TIME_1705
## iProperties
Created: 2011-12
Part Number: TIME_1705
Document SubType Name: Modeling
Designer: taborsky
Author: taborsky
