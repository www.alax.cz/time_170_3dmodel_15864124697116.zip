# Autodesk Inventor part: TIME_1701
## iProperties
Created: 2011-12
Part Number: TIME_1701
Document SubType Name: Modeling
Designer: taborsky
Author: taborsky
## Feature names
1. Base1
