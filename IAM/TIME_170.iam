# Autodesk Inventor assembly: TIME_170
## iProperties
Created: 2011-12
Part Number: TIME_170
Document SubType Name: Assembly
Designer: taborsky
Author: taborsky
