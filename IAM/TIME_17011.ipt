# Autodesk Inventor part: TIME_17011
## iProperties
Created: 2011-12
Part Number: TIME_17011
Document SubType Name: Modeling
Designer: taborsky
Author: taborsky
## Feature names
1. Base1
